# Keil uVision project ONE_WIRE.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ONE_WIRE
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_LIB_DRIVER
  c include: ..\RTOS_MYPROJECT;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\src;.\STM32F4xx_StdPeriph_Driver\inc;.\RTOS;.\RTOS\include;.\TraceRecorder;.\TraceRecorder\config;.\TraceRecorder\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c main.h
  group FreeRTOS
    ../../ARM_PROJECTS/RTOS_MYPROJECT/RTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c port.c heap_4.c
    ./: FreeRTOSConfig.h
  group Perpherials
    ./: Retar.c USART2.c USART2.h BUTTON.c BUTTON.h LED.c LED.h I2C.c I2C.h LiquidCrystal_I2C.c LiquidCrystal_I2C.h DS18B20.c DS18B20.h Delay_FUNC.c Delay_FUNC.h CTR_FAN.c CTR_FAN.h ADC_CTR_FAN.c ADC_CTR_FAN.h
  group Lib
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_gpio.c misc.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
    ./STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_rcc.h stm32f4xx_usart.h stm32f4xx_gpio.h misc.h stm32f4xx_i2c.h stm32f4xx_syscfg.h stm32f4xx_exti.h
  group Trace_lib
    ./TraceRecorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
    ./: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h
    ./TraceRecorder/streamports/USB_CDC/: trcStreamingPort.c
    ./TraceRecorder/streamports/USB_CDC/include/: trcStreamingPort.h
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2
